# Keil uVision project Brick.uvprojx, settings and files
target STM3210C-EVAL_USBH-FS (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,USE_STM3210C_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\..\Utilities\Third_Party\efsl\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c
  group STM3240_41_G_EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_sdio_sd.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group USB Host_Driver
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group USB_Device_Driver
    ../src/Com/: C_Protocol.c
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group USB_App
    ../src/: usb_bsp.c usbh_usr.c
    ../src/VCP/: usbd_usr.c usbd_desc.c usbd_cdc_vcp.c
  group LEGO_INCLUDE
    ../src/LEGO_INCLUDE/: lego_include.h
  group SYSTEM
    ../src/SYSTEM/: key.c sys.c usart1.c usart2.c usart3.c uart4.c usart6.c iic.c rng.c spi.c w25qxx.c power.c adc.c exti.c battery.c iwdg.c delay.c timer3.c
  group OUTPUT
    ../src/Output/: getspeed.c outputworkmode.c pwm.c OptimizePid.c
  group INPUT
    ../src/Input/: usart_sensor.c iic_sensor.c adc_sensor.c input.c
  group COM
    ../src/Com/: disassembly.c excutefunction.c brickperipheral.c C_Protocol.c Bluetooth.c
  group Cascade
    ../src/CASCADE/: cascade.c
  group SOUND
    ../src/SOUND/: vs10xx.c spi3.c music.c
  group FATFS
    ../src/FATFS/: myfatfs.c
    ../src/FATFS/src/: diskio.c ff.c
  group IAP
    ../src/FATFS/src/option/: cc936.c
    ../src/IAP/: flash.c iap.c flash_if.c
  group LCD
    ../src/LCD/: uc1638c.c ui_control.c ui_pic.c myfont.c text.c piano.c
  group App
    ../src/: test.c main.c stm32fxxx_it.c
target STM322xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F429VI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\Third_Party\efsl\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM322xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F429VI STMicroelectronics
  cpu: as above
  output: STM322xG-EVAL_HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM324xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\Utilities\Third_Party\efsl\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Dr_luck_Robot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Dr.luck_Robot.axf +hex
  AfterMake: C:\KeilMDK\ARM\ARMCC\bin\fromelf.exe  --bin  -o  ..\MDK-ARM\Dr.luck_Robot\Dr.luck_Robot.bin   ..\MDK-ARM\Dr.luck_Robot\Dr.luck_Robot.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\Utilities\Third_Party\efsl\inc;..\src;..\src\VCP;..\src\LEGO_INCLUDE;..\src\SYSTEM;..\src\Output;..\src\Input;..\src\Com;..\src\IAP;..\src\LCD;..\src\CASCADE;..\..\..\Libraries\CMSIS\Include;..\src\FATFS;..\src\FATFS\src;..\src\FATFS\src\option;..\src\SOUND
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
