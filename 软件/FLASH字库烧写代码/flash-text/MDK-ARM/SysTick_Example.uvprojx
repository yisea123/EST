# Keil uVision project SysTick_Example.uvprojx, settings and files
target flash-text (ARM-ADS)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SysTick_Example +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,
  c include: .\SysTick_Example;..\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\IIC;..\24CXX;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F429I-Discovery;.\LCD;.\LED;.\SPI;.\TEXT;.\W25QXX;.\SYSTEM;..\..\flash-text;..\..\flash-text（修改版）
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F429I-Discovery
    ../STM32F429I-Discovery/: stm32f429i_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_spi.c
  group User
    ./../: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../IIC/: sys.c
    ./SYSTEM/: delay.c usart6.c
  group Hardware
    ./LCD/: uc1638c.c
    ./SPI/: spi.c
    ./TEXT/: fontupd.c text.c
    ./W25QXX/: w25qxx.c
    ./SYSTEM/: piano.c
